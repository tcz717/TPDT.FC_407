# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .;..\..\rtt\rt-thread-2.0.0_beta\components\dfs;..\..\rtt\rt-thread-2.0.0_beta\components\dfs\filesystems\romfs;..\..\rtt\rt-thread-2.0.0_beta\components\dfs\include;..\..\rtt\rt-thread-2.0.0_beta\components\drivers\include;..\..\rtt\rt-thread-2.0.0_beta\components\finsh;..\..\rtt\rt-thread-2.0.0_beta\components\init;..\..\rtt\rt-thread-2.0.0_beta\include;..\..\rtt\rt-thread-2.0.0_beta\libcpu\arm\common;..\..\rtt\rt-thread-2.0.0_beta\libcpu\arm\cortex-m4;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;.\drivers\eMPL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: Motor.c PID.c PWM.c ahrs.c board.c hardtimer.c led.c serial.c settings.c spi2.c stm32_iic.c stm32f4xx_it.c usart.c
    ./drivers/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./drivers/: sonar.c hmc5883.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../rtt/rt-thread-2.0.0_beta/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../rtt/rt-thread-2.0.0_beta/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../rtt/rt-thread-2.0.0_beta/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../rtt/rt-thread-2.0.0_beta/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../rtt/rt-thread-2.0.0_beta/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rtt/rt-thread-2.0.0_beta/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group DeviceDrivers
    ../../rtt/rt-thread-2.0.0_beta/components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../rtt/rt-thread-2.0.0_beta/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
  group finsh
    ../../rtt/rt-thread-2.0.0_beta/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../rtt/rt-thread-2.0.0_beta/components/init/: components.c
